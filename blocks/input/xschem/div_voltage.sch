** sch_path: blocks/input/xschem/div_voltage.sch
**.subckt div_voltage vss v1 v2
*.iopin vss
*.iopin v1
*.iopin v2
R1 v1 net1 4k m=1
R2 net1 v2 4k m=1
**.ends
.end
